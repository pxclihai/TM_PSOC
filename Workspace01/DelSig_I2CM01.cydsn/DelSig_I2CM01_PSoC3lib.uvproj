# Keil uVision project DelSig_I2CM01_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: DelSig_I2CM01_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h ADC_DelSig.c ADC_DelSig.h ADC_DelSig_PM.c ADC_DelSig_INT.c AMuxSeq.c AMuxSeq.h Mux_7.c Mux_7.h Mux_7_aliases.h Mux_6.c Mux_6.h Mux_6_aliases.h Mux_5.c Mux_5.h Mux_5_aliases.h Mux_4.c Mux_4.h Mux_4_aliases.h Mux_3.c Mux_3.h Mux_3_aliases.h Mux_2.c Mux_2.h Mux_2_aliases.h Mux_1.c Mux_1.h Mux_1_aliases.h LCD_Char.c LCD_Char.h LCD_Char_PM.c Mux_0.c Mux_0.h Mux_0_aliases.h Pin_Ground.c Pin_Ground.h Pin_Ground_aliases.h IDAC8.c IDAC8.h IDAC8_PM.c Current_Source.c Current_Source.h Current_Source_aliases.h SDA.c SDA.h SDA_aliases.h SCL.c SCL.h SCL_aliases.h I2CM.c I2CM.h I2CM_BOOT.c I2CM_INT.c I2CM_PM.c I2CM_SLAVE.c I2CM_MASTER.c I2CM_PVT.h ADC_DelSig_Ext_CP_Clk.c ADC_DelSig_Ext_CP_Clk.h ADC_DelSig_IRQ.c ADC_DelSig_IRQ.h ADC_DelSig_theACLK.c ADC_DelSig_theACLK.h LCD_Char_LCDPort.c LCD_Char_LCDPort.h LCD_Char_LCDPort_aliases.h cycodeshareimport.ld cycodeshareimport.scat CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: DelSig_I2CM01_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
